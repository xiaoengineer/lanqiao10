# Keil uVision project program.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: program +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\FWLib;.\HARDWAER;.\USER
  group COER
    ./: STARTUP.A51
  group FWLib
    ./FWLib/: iic.c
  group USER
    ./USER/: main.c
  group HAEDWAER
    ./HARDWAER/: display.c display.h key.c key.h pcf8951.c pcf8951.h
